options:
  parameters:
    generate_options: no_gui
    id: std_t98_rf_backend
    output_language: python
    run_options: run
    title: STD-T98 RF Backend
  states: {}

blocks:
- name: Fs
  id: variable
  parameters:
    value: samp_rate/decimation
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: deltaF
  id: variable
  parameters:
    value: '315'
  states: {}
- name: err_offset
  id: variable
  parameters:
    value: '-340'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 351.2e6
  states: {}
- name: offset
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 960e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '40'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'False'
    ramp: '0'
    threshold: '-25'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: Fs/(2*math.pi*deltaF)
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: offset
    sample_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.23'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '5'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.1'
    loop_bw: '0.06'
    max_dev: '0.02'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '40'
    ted_gain: '0.1'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import numpy as np
      from gnuradio import gr
      import pmt

      class sync_word_correlator(gr.sync_block):
          """
          入力: float32 ストリーム（シンボル系列）
          出力(メッセージ): "packet_out"（PDU: f32vector, 長さ packet_len）
          仕様: 相関が閾値以上になったら、その時点の窓（同期ワード長）を先頭に据え、
                以後のシンボルを足して packet_len に達したら PDU として送出する。
                また、入力シンボルの異常値をクリッピングして誤検出を防ぐ。
          """
          def __init__(self,
                       sync_word=None,
                       threshold_ratio=0.9,
                       packet_len=192,
                       abs_limit=4.0):  # 追加: シンボルの絶対値の上限
              gr.sync_block.__init__(
                  self,
                  name="Sync Word Correlator",
                  in_sig=[np.float32],
                  out_sig=None  # ストリーム出力はない
              )

              if sync_word is None:
                  sync_word = [-3.0, +1.0, -3.0, +3.0, -3.0, -3.0, +3.0, +3.0, -1.0, +3.0]
              self.sync_word = np.asarray(sync_word, dtype=np.float32)
              self.sw_len = len(self.sync_word)

              sw_energy = float(np.dot(self.sync_word, self.sync_word))
              self.correlation_threshold = sw_energy * float(threshold_ratio)

              self.shift_register = np.zeros(self.sw_len, dtype=np.float32)

              self.packet_len = int(packet_len)
              if self.packet_len < self.sw_len:
                  raise ValueError("packet_len must be >= length of sync_word")
              self.collecting = False
              self.packet_buf = None
              self.samples_collected = 0

              # 追加: 入力シンボルのクリッピング閾値
              self.abs_limit = float(abs_limit)

              self.message_port_register_out(pmt.intern("packet_out"))

          def _start_collection(self, initial_window):
              self.packet_buf = np.empty(self.packet_len, dtype=np.float32)
              self.packet_buf[:self.sw_len] = initial_window
              self.samples_collected = self.sw_len
              self.collecting = True

          def _append_symbol(self, s):
              if not self.collecting:
                  return
              if self.samples_collected < self.packet_len:
                  self.packet_buf[self.samples_collected] = float(s)
                  self.samples_collected += 1
              if self.samples_collected >= self.packet_len:
                  # PDU（meta は空辞書）で出力
                  meta = pmt.make_dict()
                  payload = pmt.init_f32vector(self.packet_len, self.packet_buf.tolist())
                  self.message_port_pub(pmt.intern("packet_out"), pmt.cons(meta, payload))
                  # リセット
                  self.collecting = False
                  self.packet_buf = None
                  self.samples_collected = 0

          def work(self, input_items, output_items):
              in_data = input_items[0]
              nread = len(in_data)

              for i in range(nread):
                  x = float(in_data[i])

                  # --- ここからが修正点 ---
                  # 入力シンボルの値が異常に大きい場合はクリッピングする。
                  # これにより、ノイズによる極端な値が相関値に影響を与えるのを防ぐ。
                  if x > self.abs_limit:
                      x = self.abs_limit
                  elif x < -self.abs_limit:
                      x = -self.abs_limit
                  # --- 修正点ここまで ---

                  # パケット収集中かどうかで処理を分岐
                  if self.collecting:
                      self._append_symbol(x)
                  else:
                      # 同期ワード探索中
                      # シフトレジスタ更新
                      self.shift_register[:-1] = self.shift_register[1:]
                      self.shift_register[-1] = x

                      # 相関値計算
                      corr = float(np.dot(self.shift_register, self.sync_word))

                      # 閾値判定
                      if corr >= self.correlation_threshold:
                          self._start_collection(self.shift_register.copy())
              
              # 消費した入力サンプル数を返す
              return nread
    abs_limit: '4.0'
    packet_len: '192'
    sync_word: '[-3.0, +1.0, -3.0, +3.0, -3.0, -3.0, +3.0, +3.0, -1.0, +3.0]'
    threshold_ratio: '0.85'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_f32_passthrough(gr.basic_block):
          """
          入力(メッセージ): "in"  （PDU: f32vector）
          出力(メッセージ): "out" （PDU: f32vector）
          仕様: 入力のfloat値をそのまま出力します。
               enforce_len が指定されている場合、長さのチェックまたはクリップを行います。
          """
          def __init__(self, enforce_len=192, action="clip"):
              gr.basic_block.__init__(self, name="pdu_f32_passthrough",
                                      in_sig=[], out_sig=[])
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self._handle_pdu)

              self.enforce_len = int(enforce_len)
              self.action = str(action)
              
              # ハード判定用のレベル設定(_levels)は削除しました

          # _slice_indices メソッドは不要なため削除しました

          def _handle_pdu(self, pdu):
              # PDU(pair) 以外は捨てる
              if not pmt.is_pair(pdu):
                  return
              meta = pmt.car(pdu)
              vec  = pmt.cdr(pdu)
              
              # f32vector 以外は捨てる
              if not pmt.is_f32vector(vec):
                  return

              # numpy 配列に変換 (float32)
              arr = np.asarray(pmt.f32vector_elements(vec), dtype=np.float32)

              n = arr.size
              if n == 0:
                  return

              # 長さの扱い（clip / reject の処理）
              if self.enforce_len > 0 and n != self.enforce_len:
                  if self.action == "reject":
                      # 長さが合わない場合はパケットを破棄
                      return
                  elif self.action == "clip":
                      # 指定長より長い場合は切り詰め、短い場合はそのまま（あるいはパディングが必要なら別途実装）
                      # ここでは元のロジックに従い、長い場合のみ切り詰める挙動となります
                      if n > self.enforce_len:
                          arr = arr[:self.enforce_len]
                      # 短い場合をどうするかは要件次第ですが、ここでは何もしません
              
              # --- 変更点 ---
              # スライス(ハード判定)を行わず、float値をそのままペイロードにする
              
              # f32vector を作成（List[float] を渡す）
              # arr.tolist() で Python の float リストに変換してから PMT を作成
              payload = pmt.init_f32vector(int(arr.size), arr.tolist())

              # メタは空辞書で統一（元のコードの挙動を維持）
              # 必要であれば input の meta をそのまま使ってください: out_meta = meta
              out_meta = pmt.make_dict()

              # PDU で送出
              self.message_port_pub(pmt.intern("out"), pmt.cons(out_meta, payload))
    action: '"reject"'
    enforce_len: '192'
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import numpy as np
      from gnuradio import gr
      import pmt

      class pdu_f32_hardslice_to_u8(gr.basic_block):
          """
          入力(メッセージ): "in"  （PDU: f32vector）
          出力(メッセージ): "out" （PDU: u8vector, 各要素は 0,1,2,3）
          仕様: 最近傍の4値 {-3,-1,1,3} によるハード判定でインデックス 0..3 を出力。
               PDUペアのみ受理。型が違う・空・その他不整合は静かに捨てる。
          """
          def __init__(self, enforce_len=192, action="clip"):
              gr.basic_block.__init__(self, name="pdu_f32_hardslice_to_u8",
                                      in_sig=[], out_sig=[])
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self._handle_pdu)

              self.enforce_len = int(enforce_len)
              self.action = str(action)

              self._levels = np.asarray([+1.0, +3.0, -1.0, -3.0], dtype=np.float32)

          def _slice_indices(self, arr_f32):
              diff = arr_f32[:, None] - self._levels[None, :]
              idx = np.argmin(diff * diff, axis=1).astype(np.uint8)  # 0..3
              return idx

          def _handle_pdu(self, pdu):
              # PDU(pair) 以外は捨てる
              if not pmt.is_pair(pdu):
                  return
              meta = pmt.car(pdu)
              vec  = pmt.cdr(pdu)
              if not pmt.is_f32vector(vec):
                  return

              # --- 修正点 ---
              # f32vector から numpy 配列に変換する際、dtypeをfloat32のままにする
              arr = np.asarray(pmt.f32vector_elements(vec), dtype=np.float32)
              # --- ここまで ---

              n = arr.size
              if n == 0:
                  return

              # 長さの扱い（clip / reject の最小限のみ）
              if self.enforce_len > 0 and n != self.enforce_len:
                  if self.action == "reject":
                      return
                  elif self.action == "clip":
                      arr = arr[:self.enforce_len]
              
              # 正しい浮動小数点数の配列でスライス処理を実行
              idx = self._slice_indices(arr)  # uint8, 0..3
              
              # 新しいPDUのペイロード長を決定
              payload_len = idx.size

              # u8vector を作成（List[int] を渡す）
              payload = pmt.init_u8vector(int(payload_len), idx.tolist())

              # メタは空辞書で統一（最小構成）
              out_meta = pmt.make_dict()

              # PDU で送出
              self.message_port_pub(pmt.intern("out"), pmt.cons(out_meta, payload))
    action: '"reject"'
    enforce_len: '192'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Sync Word Detection using Correlation and Peak Output
      """

      import numpy as np
      from gnuradio import gr

      class sync_word_correlator(gr.sync_block):
          """
          Looks for a specific sync word in a float stream using correlation.
          It continuously calculates and outputs the correlation value (dot product)
          between the sync word and the current window of symbols.
          It also prints a message when the correlation is above a threshold,
          indicating a peak.
          """
          def __init__(self, 
                       abs_limit=4.0):
              gr.sync_block.__init__(self,
                  name = "Sync Word Correlator",
                  in_sig = [np.float32],
                  out_sig = [np.float32]) # 出力もfloat型
              # 検出したい同期ワード (テンプレート)
              # 計算効率のためにNumpy配列に変換しておく
              self.sync_word = np.array([-3.0, +1.0, -3.0, +3.0, -3.0, -3.0, +3.0, +3.0, -1.0, +3.0], dtype=np.float32)

              # ピークとみなすための相関値の閾値
              # 完全に一致した場合の自己相関値は sum(sync_word[i]^2) = 74.0 となる
              # ここでは、自己相関値の90%を閾値として設定する
              self.correlation_threshold = np.dot(self.sync_word, self.sync_word) * 0.9 
              
              # シフトレジスタをNumpy配列として初期化
              self.shift_register = np.zeros(len(self.sync_word), dtype=np.float32)

              self.abs_limit = float(abs_limit)

          def work(self, input_items, output_items):
              # input_items[0] は入力ストリームデータ (Numpy配列)
              # output_items[0] は出力ストリームデータ (Numpy配列)
              in_data = input_items[0]
              out_data = output_items[0]

              # 入力された各シンボルを一つずつ処理
              for i in range(len(in_data)):
                  current_symbol = in_data[i]

                  # 入力シンボルの値が異常に大きい場合はクリッピングする。
                  # これにより、ノイズによる極端な値が相関値に影響を与えるのを防ぐ。
                  if current_symbol > self.abs_limit:
                      current_symbol = self.abs_limit
                  elif current_symbol < -self.abs_limit:
                      current_symbol = -self.abs_limit
                  
                  # シフトレジスタを更新 (np.rollは効率的なシフト操作)
                  # 1. 配列全体を左に1つ循環シフト
                  self.shift_register = np.roll(self.shift_register, -1)
                  # 2. 末尾の要素(もともと先頭にあった古い値)を新しいシンボルで上書き
                  self.shift_register[-1] = current_symbol

                  # --- ここが重要な変更点 ---
                  # 現在のシフトレジスタと同期ワードとの相関 (内積) を計算
                  correlation_value = np.dot(self.shift_register, self.sync_word)
                  
                  # 計算した相関値を出力ストリームに書き込む
                  out_data[i] = correlation_value
                  
              # 処理した (そして出力した) アイテム数を返す
              return len(out_data)
    abs_limit: '4.0'
  states: {state: disabled}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: '[-4.65537794980264e-07, -5.05292007346725e-07, -5.41911958862329e-07, -5.74309069634182e-07, -6.0135340618217e-07, -6.21887750185124e-07, -6.34743457794684e-07, -6.38757001070189e-07, -6.32788385246386e-07, -6.15740077591909e-07, -5.86577414196654e-07, -5.44348608855216e-07, -4.88206239879219e-07, -4.17428083210325e-07, -3.31437775002996e-07, -2.29825403152972e-07, -1.12366912219386e-07, 2.09575272691609e-08, 1.69946574146707e-07, 3.34162564286089e-07, 5.12918575168442e-07, 7.05267609646398e-07, 9.0999509438916e-07, 1.1256136076554e-06, 1.35036168558145e-06, 1.58220507273654e-06, 1.81884331595938e-06, 2.0577183477144e-06, 2.2960282421991e-06, 2.53074540523812e-06, 2.75863726528769e-06, 2.9762927624688e-06, 3.18015190714505e-06, 3.36653988597391e-06, 3.5317038964422e-06, 3.67185543836968e-06, 3.7832126054127e-06, 3.86204919777811e-06, 3.90474315281608e-06, 3.90782770409714e-06, 3.86804549634689e-06, 3.78240224563342e-06, 3.64822017218103e-06, 3.46319257005234e-06, 3.22543701258837e-06, 2.93354582936445e-06, 2.5866354462778e-06, 2.18439186028263e-06, 1.72711224877276e-06, 1.21574237255118e-06, 6.51908294457826e-07, 3.79419589080499e-08, -6.23099424501561e-07, -1.3274217280923e-06, -2.07048992706405e-06, -2.84703264696873e-06, -3.65105483979278e-06, -4.47586126028909e-06, -5.31408613824169e-06, -6.15773706158507e-06, -6.99824386174441e-06, -7.82651932240697e-06, -8.63303193909815e-06, -9.407877769263e-06, -1.0140878657694e-05, -1.08216681837803e-05, -1.1439800800872e-05, -1.1984862794634e-05, -1.24465850603883e-05, -1.28149658848997e-05, -1.30803964566439e-05, -1.32337900140556e-05, -1.32667082652915e-05, -1.31714923554682e-05, -1.29413874674356e-05, -1.25706728795194e-05, -1.20547765618539e-05, -1.13903925011982e-05, -1.05755862023216e-05, -9.60989109444199e-06, -8.49439493322279e-06, -7.23181437933818e-06, -5.82655457037617e-06, -4.28475323133171e-06, -2.61431068793172e-06, -8.24899757390085e-07, 1.07204164123686e-06, 3.06333799926506e-06, 5.13412351210718e-06, 7.26790904082009e-06, 9.44667317526182e-06, 1.16509700092138e-05, 1.38600616992335e-05, 1.60520685312804e-05, 1.82041403604671e-05, 2.0292647604947e-05, 2.22933904296951e-05, 2.41818197537214e-05, 2.59332828136394e-05, 2.75232687272364e-05, 2.89276777039049e-05, 3.0123093893053e-05, 3.10870600515045e-05, 3.17983613058459e-05, 3.2237312552752e-05, 3.23860331263859e-05, 3.22287269227672e-05, 3.17519443342462e-05, 3.09448478219565e-05, 2.97994338325225e-05, 2.83107783616288e-05, 2.64772170339711e-05, 2.43005306401756e-05, 2.17860942939296e-05, 1.89429902093252e-05, 1.57840931933606e-05, 1.23261261251173e-05, 8.58966359373881e-06, 4.59910597783164e-06, 3.82613450256031e-07, -4.02801060772617e-06, -8.59747160575353e-06, -1.32871809910284e-05, -1.80555016413564e-05, -2.2858028387418e-05, -2.76479167951038e-05, -3.23762469633948e-05, -3.69924346159678e-05, -4.1444662201684e-05, -4.56803645647597e-05, -4.96467218908947e-05, -5.32911944901571e-05, -5.65620794077404e-05, -5.94090670347214e-05, -6.17838159087114e-05, -6.36405748082325e-05, -6.49367066216655e-05, -6.56333286315203e-05, -6.56958436593413e-05, -6.50945075904019e-05, -6.38049605186097e-05, -6.18086996837519e-05, -5.90935560467187e-05, -5.56541090190876e-05, -5.14920393470675e-05, -4.66164565295912e-05, -4.10441280109808e-05, -3.47996719938237e-05, -2.79156665783376e-05, -2.04326788662001e-05, -1.23992322187405e-05, -3.87166892323876e-06, 5.08605353388702e-06, 1.44026598718483e-05, 2.39999408222502e-05, 3.3793221518863e-05, 4.36919181083795e-05, 5.36001789441798e-05, 6.34175885352306e-05, 7.30399988242425e-05, 8.23603695607744e-05, 9.12696923478507e-05, 9.96580565697514e-05, 0.000107415609818418, 0.00011443372204667, 0.000120606113341637, 0.000125829959870316, 0.000130007159896195, 0.00013304541062098, 0.000134859496029094, 0.000135372349177487, 0.000134516260004602, 0.000132233908516355, 0.000128479427075945, 0.000123219360830262, 0.000116433577204589, 0.000108115993498359, 9.82753772404976e-05, 8.69358409545384e-05, 7.41373441996984e-05, 5.99360064370558e-05, 4.44042925664689e-05, 2.76310474873753e-05, 9.72136422205949e-06, -9.20368711376796e-06, -2.90075204247842e-05, -4.95386484544724e-05, -7.06314604030922e-05, -9.21072060009465e-05, -0.000113775080535561, -0.000135433539981022, -0.000156871727085672, -0.000177871057530865, -0.000198206995264627, -0.000217650842387229, -0.000235971790971234, -0.000252938974881545, -0.00026832363801077, -0.000281901389826089, -0.000293454533675686, -0.000302774336887524, -0.000309663446387276, -0.0003139381587971, -0.000315430865157396, -0.000313992088194937, -0.00030949292704463, -0.000301826978102326, -0.00029091231408529, -0.000276693346677348, -0.000259142543654889, -0.000238261709455401, -0.000214083469472826, -0.000186672128620557, -0.000156124544446357, -0.000122570607345551, -8.617350977147e-05, -4.71296480100136e-05, -5.66831340620411e-06, 3.79489938495681e-05, 8.34295569802634e-05, 0.000130450731376186, 0.000178661604877561, 0.000227684882702306, 0.000277119193924591, 0.000326541718095541, 0.000375510862795636, 0.000423569581471384, 0.000470248720375821, 0.000515070685651153, 0.000557553197722882, 0.000597213511355221, 0.000633572519291192, 0.000666159146931022, 0.000694514950737357, 0.000718198309186846, 0.000736789254005998, 0.000749894068576396, 0.000757149362470955, 0.000758227019105107, 0.000752837979234755, 0.000740736722946167, 0.000721724762115628, 0.000695654540322721, 0.000662432692479342, 0.000622022955212742, 0.000574448669794947, 0.000519795285072178, 0.000458211725344881, 0.000389911903766915, 0.000315175391733646, 0.000234347724472173, 0.000147839935380034, 5.61278466193471e-05, -4.0249535231851e-05, -0.000140691961860284, -0.000244540628045797, -0.000351081427652389, -0.000459548609796911, -0.000569129420910031, -0.000678968674037606, -0.000788174627814442, -0.000895824457984418, -0.00100097118411213, -0.0011026500724256, -0.00119988631922752, -0.00129170238506049, -0.00137712561991066, -0.00145519734360278, -0.00152497983071953, -0.00158556597307324, -0.00163608696311712, -0.00167572090867907, -0.00170370156411082, -0.0017193261301145, -0.00172196363564581, -0.00171106203924865, -0.00168615649454296, -0.00164687517099082, -0.00159294658806175, -0.00152420473750681, -0.00144059467129409, -0.00134217669256032, -0.00122913019731641, -0.00110175646841526, -0.000960480596404523, -0.000805853109341115, -0.000638549332506955, -0.000459369242889807, -0.000269235344603658, -6.91898967488669e-05, 0.000139608848257922, 0.000355891621438786, 0.000578283914364874, 0.000805312942247838, 0.00103541545104235, 0.00126694678328931, 0.00149818998761475, 0.00172736716922373, 0.00195265049114823, 0.00217217393219471, 0.00238404702395201, 0.00258636754006147, 0.00277723534964025, 0.00295476731844246, 0.00311711151152849, 0.00326246209442616, 0.00338907446712255, 0.00349528016522527, 0.00357950199395418, 0.00364026846364141, 0.00367622799240053, 0.00368616380728781, 0.00366900535300374, 0.00362384342588484, 0.00354993995279074, 0.00344674033112824, 0.00331388297490776, 0.00315120862796903, 0.00295876734890044, 0.00273682572878897, 0.00248587201349437, 0.00220661936327815, 0.00190000853035599, 0.001567208673805, 0.00120961631182581, 0.000828852935228497, 0.000426760903792456, 5.3980429584044e-06, -0.000432969856774434, -0.000885877932887524, -0.00135067268274724, -0.00182452390436083, -0.00230443850159645, -0.00278727547265589, -0.0032697613351047, -0.00374850910156965, -0.00422003632411361, -0.00468078488484025, -0.00512714171782136, -0.0055554611608386, -0.00596208637580276, -0.00634337402880192, -0.00669571477919817, -0.00701555982232094, -0.00729944230988622, -0.00754400342702866, -0.00774601334705949, -0.00790239684283733, -0.00801025331020355, -0.00806688144803047, -0.00806979835033417, -0.00801676046103239, -0.00790578313171864, -0.00773515552282333, -0.00750346109271049, -0.0072095887735486, -0.00685274694114923, -0.00643247598782182, -0.00594865623861551, -0.00540151447057724, -0.00479163229465485, -0.00411994522437453, -0.00338774803094566, -0.00259668938815594, -0.00174877198878676, -0.000846344279125333, 0.00010790559463203, 0.00111096072942019, 0.0021594874560833, 0.00324984965845942, 0.00437812460586429, 0.0055401218123734, 0.00673140306025743, 0.00794730428606272, 0.00918295700103045, 0.0104333171620965, 0.011693187057972, 0.0129572479054332, 0.0142200822010636, 0.0154762053862214, 0.0167200993746519, 0.0179462395608425, 0.0191491208970547, 0.020323297008872, 0.0214634090662003, 0.0225642118602991, 0.0236206036061049, 0.0246276613324881, 0.0255806632339954, 0.0264751184731722, 0.0273067932575941, 0.0280717313289642, 0.0287662837654352, 0.0293871257454157, 0.0299312770366669, 0.0303961168974638, 0.0307794045656919, 0.031079288572073, 0.0312943235039711, 0.0314234606921673, 0.0314660854637623, 0.0314219892024994, 0.0312913879752159, 0.0310749188065529, 0.0307736322283745, 0.030388992279768, 0.0299228578805923, 0.0293774828314781, 0.0287554953247309, 0.0280598867684603, 0.0272939912974834, 0.0264614652842283, 0.0255662705749273, 0.0246126502752304, 0.0236050970852375, 0.0225483402609825, 0.02144730463624, 0.0203070938587189, 0.0191329531371593, 0.0179302450269461, 0.0167044121772051, 0.0154609577730298, 0.0142054026946425, 0.0129432631656528, 0.0116800172254443, 0.0104210739955306, 0.00917174853384495, 0.00793722923845053, 0.00672255316749215, 0.00553257670253515, 0.00437195552513003, 0.00324511690996587, 0.00215624086558819, 0.00110923801548779, 0.000107733161712531, -0.000844951835460961, -0.00174581201281399, -0.00259217130951583, -0.0033816930372268, -0.00411238661035895, -0.00478261336684227, -0.00539109157398343, -0.00593689503148198, -0.00641945237293839, -0.00683854660019279, -0.00719430530443788, -0.00748719740658998, -0.00771802105009556, -0.00788789335638285, -0.00799823738634586, -0.0080507667735219, -0.00804747082293034, -0.00799059495329857, -0.00788262486457825, -0.00772626139223576, -0.00752440467476845, -0.00728012807667255, -0.00699665956199169, -0.00667735375463963, -0.00632567377761006, -0.00594516238197684, -0.00553942285478115, -0.00511209201067686, -0.0046668192371726, -0.00420724088326097, -0.00373696186579764, -0.00325953005813062, -0.00277841836214066, -0.0022970037534833, -0.0018185485387221, -0.00134618335869163, -0.000882890250068158, -0.000431488471804187, 5.37930964128464e-06, 0.000425258942414075, 0.00082589517114684, 0.00120524037629366, 0.00156146206427366, 0.00189294794108719, 0.00219831033609807, 0.00247638882137835, 0.00272624986246228, 0.00294718728400767, 0.0031387188937515, 0.00330058392137289, 0.00343273649923503, 0.00353533984161913, 0.00360875856131315, 0.00365354912355542, 0.00367045076563954, 0.00366037315689027, 0.00362438568845391, 0.00356370420195162, 0.00347967795096338, 0.0033737753983587, 0.00324756954796612, 0.00310272467322648, 0.00294098001904786, 0.00276413536630571, 0.00257403613068163, 0.00237255869433284, 0.00216159550473094, 0.00194304110482335, 0.00171877793036401, 0.00149066338781267, 0.0012605165829882, 0.00103010702878237, 0.000801142596174031, 0.000575259269680828, 0.000354011717718095, 0.00013886415399611, -6.88172221998684e-05, -0.000267771101789549, -0.000456846959423274, -0.000635009782854468, -0.000801343820057809, -0.000955055525992066, -0.00109547527972609, -0.00122205796651542, -0.00133438291959465, -0.00143215293064713, -0.00151519186329097, -0.00158344232477248, -0.00163696112576872, -0.00167591555509716, -0.00170057802461088, -0.00171132001560181, -0.00170860614161938, -0.00169298681430519, -0.00166509125847369, -0.00162561982870102, -0.00157533574383706, -0.00151505717076361, -0.00144564895890653, -0.00136801402550191, -0.00128308474086225, -0.00119181512854993, -0.00109517190139741, -0.000994127127341926, -0.000889649498276412, -0.000782697694376111, -0.000674212700687349, -0.000565110880415887, -0.000456277979537845, -0.000348562956787646, -0.000242772599449381, -0.000139666779432446, -3.99539567297325e-05, 5.57124658371322e-05, 0.000146737380418926, 0.000232586549827829, 0.000312788644805551, 0.000386936677386984, 0.000454688823083416, 0.000515768711920828, 0.000569965282920748, 0.000617131940089166, 0.00065718509722501, 0.000690102868247777, 0.00071592244785279, 0.000734737724997103, 0.000746696314308792, 0.000751996180042624, 0.000750882143620402, 0.000743641925510019, 0.000730602128896862, 0.000712123874109238, 0.000688598782289773, 0.000660444027744234, 0.000628098321612924, 0.00059201690601185, 0.000552667421288788, 0.000510525424033403, 0.000466069934191182, 0.000419779302319512, 0.000372127222362906, 0.000323578889947385, 0.000274587422609329, 0.000225590381887741, 0.000177006775629707, 0.000129234176711179, 8.26461910037324e-05, 3.75902418454643e-05, -5.61436354473699e-06, -4.66780365968589e-05, -8.53421879583038e-05, -0.000121380195196252, -0.000154598063090816, -0.000184834731044248, -0.000211962178582326, -0.000235885105212219, -0.000256540428381413, -0.000273896584985778, -0.000287952367216349, -0.000298735685646534, -0.000306302245007828, -0.000310733710648492, -0.00031213607871905, -0.000310637493385002, -0.000306386442389339, -0.000299549341434613, -0.000290308467810974, -0.000278859544778243, -0.000265409529674798, -0.000250174169195816, -0.000233375787502155, -0.000215240943362005, -0.000195998247363605, -0.000175876193679869, -0.0001551010645926, -0.000133895067847334, -0.000112474372144789, -9.10474773263559e-05, -6.98136354913004e-05, -4.89613921672571e-05, -2.86673548544059e-05, -9.09507070900872e-06, 9.60591023613233e-06, 2.73008099611616e-05, 4.38702263636515e-05, 5.921056799707e-05, 7.32343396521173e-05, 8.5870262410026e-05, 9.70632027019747e-05, 0.000106774023151956, 0.000114979251520708, 0.00012167059321655, 0.000126854371046647, 0.000130550834001042, 0.000132793371449225, 0.000133627589093521, 0.00013311042857822, 0.000131309032440186, 0.000128299783682451, 0.000124167068861425, 0.00011900225217687, 0.000112902402179316, 0.000105969178548548, 9.83076679403894e-05, 9.00252198334783e-05, 8.12303260318004e-05, 7.20315510989167e-05, 6.25365064479411e-05, 5.28508135175798e-05, 4.30772415711544e-05, 3.33148200297728e-05, 2.36580453929491e-05, 1.41961945701041e-05, 5.0126855057897e-06, -3.81546715289005e-06, -1.22181099868612e-05, -2.01323291548761e-05, -2.75027323368704e-05, -3.42816601914819e-05, -4.04293059546035e-05, -4.5913751819171e-05, -5.07109289173968e-05, -5.48045136383735e-05, -5.81857348151971e-05, -6.08531408943236e-05, -6.28122725174762e-05, -6.40753205516376e-05, -6.46606786176562e-05, -6.45925538265146e-05, -6.3900399254635e-05, -6.26184555585496e-05, -6.07851652603131e-05, -5.84426306886598e-05, -5.56360428163316e-05, -5.24130882695317e-05, -4.88233854412101e-05, -4.49179096904118e-05, -4.07484258175828e-05, -3.63669569196645e-05, -3.18252605211455e-05, -2.71743319899542e-05, -2.2463931600214e-05, -1.77421661646804e-05, -1.30550815811148e-05, -8.44630267238244e-06, -3.95671941078035e-06, 3.75796815887952e-07, 4.51662481282256e-06, 8.43459019961301e-06, 1.21021121231024e-05, 1.54953158926219e-05, 1.85940934898099e-05, 2.13821313082008e-05, 2.38469019677723e-05, 2.59796070167795e-05, 2.77750914392527e-05, 2.92317345156334e-05, 3.0351291570696e-05, 3.11387266265228e-05, 3.16020086756907e-05, 3.17518970405217e-05, 3.16017030854709e-05, 3.11670337396208e-05, 3.04655332001857e-05, 2.95166064461228e-05, 2.8341146389721e-05, 2.69612537522335e-05, 2.53999623964773e-05, 2.3680961021455e-05, 2.18283257709118e-05, 1.98662619368406e-05, 1.78188620338915e-05, 1.57098602358019e-05, 1.35624177346472e-05, 1.13989226520061e-05, 9.2407981355791e-06, 7.10833683115197e-06, 5.0205558181915e-06, 2.99506632472912e-06, 1.04796845334931e-06, -8.06235050276882e-07, -2.55470422416693e-06, -4.18630725107505e-06, -5.69164558328339e-06, -7.06306036590831e-06, -8.29462078399956e-06, -9.38209359446773e-06, -1.03229003798333e-05, -1.11160552478395e-05, -1.17620920718764e-05, -1.22629789984785e-05, -1.26220238598762e-05, -1.28437650346314e-05, -1.29338659462519e-05, -1.28989877339336e-05, -1.27466773847118e-05, -1.24852303997613e-05, -1.21235752885696e-05, -1.1671139873215e-05, -1.11377266875934e-05, -1.05333938336116e-05, -9.86833492788719e-06, -9.15276177693158e-06, -8.39680342323845e-06, -7.61039837016142e-06, -6.80320636092802e-06, -5.98452015765361e-06, -5.16318959853379e-06, -4.34755384048913e-06, -3.54538224200951e-06, -2.76382706942968e-06, -2.00938234229397e-06, -1.28785382003116e-06, -6.04338538323645e-07, 3.67878918439146e-08, 6.31874343071104e-07, 1.17798970222793e-06, 1.67291079833376e-06, 2.11510268854909e-06, 2.50369294008124e-06, 2.83844019577373e-06, 3.11969620270247e-06, 3.34836659021676e-06, 3.52586334884109e-06, 3.65405890079273e-06, 3.73523425878375e-06, 3.77202786694397e-06, 3.76738262275467e-06, 3.72449244423478e-06, 3.64675020136929e-06, 3.5376954201638e-06, 3.40096380568866e-06, 3.24024040310178e-06, 3.05921207655047e-06, 2.86152544504148e-06, 2.65074777416885e-06, 2.43032923208375e-06, 2.20357173930097e-06, 1.97359963749477e-06, 1.7433346783946e-06, 1.51547590121481e-06, 1.29248269331583e-06, 1.07656228465203e-06, 8.69660595981259e-07, 6.73457634547958e-07, 4.89366072997655e-07, 3.18533068366378e-07, 1.6184569062716e-07, 1.99388363597564e-08, -1.06793926590854e-07, -2.18187366840539e-07, -3.14289508196453e-07, -3.95344869730252e-07, -4.6177621015886e-07, -5.14165492404572e-07, -5.53233689970511e-07, -5.79820607526926e-07, -5.94864104641601e-07, -5.99379916366161e-07, -5.94441189605277e-07, -5.8115966794503e-07, -5.60666421733913e-07, -5.34094965587428e-07, -5.02564375892689e-07, -4.67164767314898e-07]'
    type: fff
  states: {}
- name: fft_filter_xxx_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.low_pass(1.0, samp_rate, 4e3, 2.5e3, window.WIN_BLACKMAN_HARRIS)
    type: ccc
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    label1: Eye Pattern
    samp_per_symbol: '1'
    size: '64'
    srate: Fs
    type: float
    update_time: 1/60
    ylabel: Symbol
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    legend: 'False'
    name: '"Sync Word Detect"'
    size: '1024'
    srate: 2.4e3
    tr_level: '65'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: correlation
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq + offset+err_offset
    gain: '30'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: sig1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: sym1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sig1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: sym1
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', virtual_sink_0, '0']
- [analog_quadrature_demod_cf_0, '0', fft_filter_xxx_0, '0']
- [blocks_freqshift_cc_0, '0', fft_filter_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', virtual_sink_1, '0']
- [blocks_throttle2_0, '0', blocks_freqshift_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [epy_block_0, packet_out, zeromq_push_msg_sink_0, in]
- [epy_block_2, '0', qtgui_time_sink_x_0, '0']
- [fft_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [fft_filter_xxx_1, '0', analog_pwr_squelch_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_1, '0', epy_block_0, '0']
- [virtual_source_1, '0', qtgui_eye_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
